# Repository uinika/UINIO-Power-LDO

File README.md:

# UINIO-Power-LDO 线性稳压器模组

[**UINIO-Power-LDO**](https://gitee.com/uinika/UINIO-Power-LDO) 是一款同时支持 **XC6206**、**ME6211**、**SGM2019**、**AMS1117** 四种常用线性稳压芯片的测试模组，采用了四合一拼板设计，可以单独拆分进行使用。

## 应用介绍

1. **XC6206** 模组：选用 **SOT-23-3** 封装，兼容**特瑞仕** `XC6206` 系列低压差线性稳压器。
2. **ME6211** 模组：选用 **SOT-23-5** 封装，兼容**微盟** `ME6211` 系列低压差线性稳压器。
3. **SGM2019** 模组：选用 **SOT-23-5** 封装，兼容**圣邦微** `SGM2019` 系列低压差线性稳压器。
4. **AMS1117** 模组：选用 **SOT-223-3** 封装，可以兼容**固定电压**版本的**艾迈斯** `AMS1117`、**德州仪器** `REG1117` 线性稳压器。

> **注意**：每一片模组都单独添加了 `2mm` 直径的非金属化固定螺丝孔。

## 设计概要

1. 采用了 6 Pin 的 **USB Type-C**，并且 `CC1` 和 `CC2` 分别添加了 `5.1kΩ` 下拉电阻，可以更好的兼容具备**功率传输协议 USB-PD**（USB Power Delivery）的电源；
2. 使用 `0.7mm` 线宽 `0.3mm` 线距、`0.8mm` 过孔 `0.3mm` 孔径进行 PCB 布线，在温升 10℃ 的情况下，最大负载电流为 `1.6A` 左右，如果需要换用其它型号的线性稳压芯片，需要注意其最大输出电流不能超过该值。
3. 支持使用 `2Pin` 的杜邦针作为电源输入端口，而 `4Pin` 的杜邦针作为两路的电源输出端口。
4. 添加有一枚用于防止**输入端**反接的 **1N5819** 肖特基二极管（最大整流电流 `1A`，最大反向工作电压 `40V`），采用大尺寸的 **SOD-123** 封装，或者也可以选择载流能力达到 `3A` 的 **1N5822**。
5. 肖特基二极管和 `4Pin` 杜邦针两端，分别添加有两组测试点，便于测量输入输出的电源纹波。

> **注意**： **AMS1117** 模组的输出电容，必须采用**等效串联电阻 ESR**（Equivalent Series Resistance）更大的 `22uF` **钽电容**，从而确保输出的稳定性。

## 参考技术文档

[UinIO.com 电子技术实验室](http://uinio.com/) 为 **UINIO-Power-LDO** 开源项目提供了如下一系列技术参考资料：

- [《常见 LDO 线性稳压芯片的对比选型》](http://uinio.com/Electronics/LDO/)
- [《BOM 交互式物料清单与 PCB 布线在线预览》](http://uinio.com/archives/BOM/UINIO-Power-LDO.html)

## KiCad design UINIO-Power-LDO.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C7: 1uF; C_0603_1608Metric
C6: 0.01uF; C_0603_1608Metric
C8: 10uF; C_0603_1608Metric
C9: 22uF; CP_EIA-3528-15_AVX-H_Pad1.50x2.35mm_HandSolder
D1, D2, D4, D6: 1N5819; Nexperia_CFP3_SOD-123W
D3, D5, D7, D8: LED_Red; LED_0603_1608Metric
J1, J2, J3, J6: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J4: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J5, J7, J8, J9: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R8, R9: 5.1k; R_0603_1608Metric
R7, R10, R11, R12: 2K; R_0603_1608Metric
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16: TestPoint; TestPoint_Pad_D1.5mm
U1: ME6211C33M5G-N; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR
U2: XC6206PxxxMR; SOT-23-3
U3: SGM2019-3.3YN5G; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR
U4: AMS1117; SOT-223-3_L6.6-W3.5-P2.30-LS7.0-BL
USB1, USB2, USB3, USB4: USB_Type_C_6Pin; USB-TYPEC-250-BRP6L68

Connections:
GND-AMS1117: C8.2, C9.2, D8.1 (K), J6.2, J8.1, J8.3, R8.1, R9.2, TP15.1, U4.1 (GND), USB4.1 (GND), USB4.2 (GND), USB4.3 (GND), USB4.4 (GND), USB4.A12 (GND), USB4.B12 (GND)
GND-ME6211: C1.1, C3.1, D3.1 (K), J1.2, J7.1, J7.3, R1.2, R2.2, TP14.1, U1.2 (Vss), USB1.1 (GND), USB1.2 (GND), USB1.3 (GND), USB1.4 (GND), USB1.A12 (GND), USB1.B12 (GND)
GND-SGM2019: C5.1, C6.1, C7.1, D5.1 (K), J3.2, J4.1, J5.1, J5.3, R5.2, R6.2, TP13.1, U3.2 (GND), USB3.1 (GND), USB3.2 (GND), USB3.3 (GND), USB3.4 (GND), USB3.A12 (GND), USB3.B12 (GND)
GND-XC6206: C2.2, C4.2, D7.1 (K), J2.2, J9.1, J9.3, R3.2, R4.2, TP16.1, U2.1 (GND), USB2.1 (GND), USB2.2 (GND), USB2.3 (GND), USB2.4 (GND), USB2.A12 (GND), USB2.B12 (GND)
unnamed: D1.2 (A), J1.1, TP1.1, USB1.A9 (VBUS), USB1.B9 (VBUS)
unnamed: C1.2, D1.1 (K), TP2.1, U1.1 (Vin), U1.3 (CE)
unnamed: D2.2 (A), J2.1, TP3.1, USB2.A9 (VBUS), USB2.B9 (VBUS)
unnamed: C2.1, D2.1 (K), TP4.1, U2.3 (VI)
unnamed: D3.2 (A), R7.1
unnamed: D4.2 (A), J3.1, TP6.1, USB3.A9 (VBUS), USB3.B9 (VBUS)
unnamed: C5.2, D4.1 (K), J4.3, TP8.1, U3.1 (IN)
unnamed: D5.2 (A), R10.1
unnamed: D6.2 (A), J6.1, TP9.1, USB4.A9 (VBUS), USB4.B9 (VBUS)
unnamed: C8.1, D6.1 (K), TP11.1, U4.3 (Vin)
unnamed: D7.2 (A), R11.1
unnamed: D8.2 (A), R12.2
unnamed: J4.2, U3.3 (EN)
unnamed: C6.2, U3.4 (FB)
unnamed: R1.1, USB1.A5 (CC1)
unnamed: R2.1, USB1.B5 (CC2)
unnamed: R3.1, USB2.A5 (CC1)
unnamed: R4.1, USB2.B5 (CC2)
unnamed: R5.1, USB3.A5 (CC1)
unnamed: R6.1, USB3.B5 (CC2)
unnamed: R8.2, USB4.A5 (CC1)
unnamed: R9.1, USB4.B5 (CC2)
VCC-AMS1117: C9.1, J8.2, J8.4, R12.1, TP12.1, U4.2 (Vout), U4.4 (Vout)
VCC-ME6211: C3.2, J7.2, J7.4, R7.2, TP5.1, U1.5 (Vout)
VCC-SGM2019: C7.2, J5.2, J5.4, R10.2, TP10.1, U3.5 (OUT)
VCC-XC6206: C4.1, J9.2, J9.4, R11.2, TP7.1, U2.2 (VO)

Notes on the sheet:
XC6206 低压差线性稳压器
SGM2019 低压差线性稳压器
ME6211 低压差线性稳压器
AMS1117 线性稳压器

Board: 2 copper layers, 40.0 x 98.3 mm, 81 parts (0 on the bottom side), 30 nets.

Other parts of the board:
HOLE**: Hole-2mm
HOLE**#2, HOLE**#3, HOLE**#4, HOLE**#5, HOLE**#6, HOLE**#7, HOLE**#9, HOLE**#10, HOLE**#11, HOLE**#12, HOLE**#13, HOLE**#15, HOLE**#16, HOLE**#17, HOLE**#19: Hole-2mm
HOLE**#8, HOLE**#14, HOLE**#18: Hole-2.6mm

## Commit log

2024-04-23 Initialization project.
2024-04-25 Finish PCB Layout.
2024-04-26 Release UINIO-Power-LDO version 1.0.0.
2024-04-26 Update README.md.
2024-04-29 Releaase UINIO-Power-LDO version 2.0.0.
